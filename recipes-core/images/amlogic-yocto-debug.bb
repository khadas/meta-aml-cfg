require amlogic-yocto.bb

IMAGE_INSTALL += "\
    iozone3 \
    fio \
    stressapptest \
    coreutils \
    cpuburn \
    "
